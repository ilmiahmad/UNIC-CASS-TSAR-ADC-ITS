v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 360 -320 0 0 {name=p2 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 360 -220 0 0 {name=p3 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 360 -240 0 0 {name=p11 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 360 -300 0 0 {name=p13 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 360 -280 0 0 {name=p14 sig_type=std_logic lab=swp_in[0:9]}
C {devices/lab_wire.sym} 660 -320 0 1 {name=p16 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 660 -300 0 1 {name=p17 sig_type=std_logic lab=vcn}
C {devices/ipin.sym} 160 -320 0 0 {name=p18 lab=vdref}
C {devices/ipin.sym} 160 -290 0 0 {name=p19 lab=cf[0:9]}
C {devices/ipin.sym} 160 -260 0 0 {name=p20 lab=swp_in[0:9]}
C {devices/ipin.sym} 160 -230 0 0 {name=p21 lab=swn_in[0:9]}
C {devices/ipin.sym} 160 -200 0 0 {name=p22 lab=vcm}
C {devices/ipin.sym} 160 -170 0 0 {name=p23 lab=vsref}
C {devices/iopin.sym} 140 -140 0 0 {name=p24 lab=vcp}
C {devices/iopin.sym} 140 -110 0 0 {name=p25 lab=vcn}
C {single_10b_cdac.sym} 510 -270 0 0 {name=x1}
C {devices/lab_wire.sym} 360 -260 0 0 {name=p78 sig_type=std_logic lab=swn_in[0:9]}
C {devices/lab_wire.sym} 360 -170 0 0 {name=p1 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 360 -70 0 0 {name=p4 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 360 -90 0 0 {name=p5 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 360 -150 0 0 {name=p6 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 360 -130 0 0 {name=p7 sig_type=std_logic lab=swp_in[0:9]}
C {devices/lab_wire.sym} 660 -170 0 1 {name=p8 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 660 -150 0 1 {name=p9 sig_type=std_logic lab=vcn}
C {single_10b_cdac.sym} 510 -120 0 0 {name=x2}
C {devices/lab_wire.sym} 360 -110 0 0 {name=p10 sig_type=std_logic lab=swn_in[0:9]}
