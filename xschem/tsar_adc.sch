v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 360 -310 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 360 -330 0 0 {name=p2 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 360 -110 0 0 {name=p5 sig_type=std_logic lab=VSSR}
C {devices/lab_wire.sym} 360 -90 0 0 {name=p6 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 820 -330 0 0 {name=p7 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 820 -230 0 0 {name=p8 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 360 -170 0 0 {name=p9 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 360 -190 0 0 {name=p10 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 1120 -230 0 1 {name=p11 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 820 -250 0 0 {name=p15 sig_type=std_logic lab=COMP_N}
C {devices/lab_wire.sym} 820 -290 0 0 {name=p17 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 360 -210 0 0 {name=p25 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 360 -290 0 0 {name=p26 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 360 -150 0 0 {name=p27 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 360 -130 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 360 -270 0 0 {name=p29 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 360 -250 0 0 {name=p30 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 360 -230 0 0 {name=p31 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 1120 -330 0 1 {name=p32 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 1120 -310 0 1 {name=p33 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 1120 -290 0 1 {name=p34 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 1120 -250 0 1 {name=p35 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 1120 -270 0 1 {name=p36 sig_type=std_logic lab=DOUT[0:9]}
C {devices/ipin.sym} 100 -310 0 0 {name=p37 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 100 -290 0 0 {name=p38 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 100 -270 0 0 {name=p39 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 100 -230 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 100 -210 0 0 {name=p41 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 100 -190 0 0 {name=p42 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 100 -150 0 0 {name=p43 sig_type=std_logic lab=VSSA}
C {devices/ipin.sym} 100 -130 0 0 {name=p44 sig_type=std_logic lab=VSSD}
C {devices/opin.sym} 80 -100 0 0 {name=p45 sig_type=std_logic lab=DOUT[0:9]}
C {devices/opin.sym} 80 -80 0 0 {name=p46 sig_type=std_logic lab=CKO}
C {devices/ipin.sym} 100 -170 0 0 {name=p14 sig_type=std_logic lab=VSSR}
C {devices/ipin.sym} 100 -330 0 0 {name=p16 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 820 -270 0 0 {name=p24 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 660 -330 0 1 {name=p13 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 660 -310 0 1 {name=p48 sig_type=std_logic lab=COMP_N}
C {devices/lab_wire.sym} 820 -310 0 0 {name=p47 sig_type=std_logic lab=EN}
C {devices/ipin.sym} 100 -250 0 0 {name=p49 sig_type=std_logic lab=EN}
C {sar.sym} 970 -270 0 0 {name=x4}
C {devices/lab_wire.sym} 1120 -210 0 1 {name=p12 sig_type=std_logic lab=CLKSB}
C {analog_block.sym} 510 -210 0 0 {name=x1}
