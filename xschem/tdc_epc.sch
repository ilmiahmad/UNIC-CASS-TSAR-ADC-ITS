v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {epc_value_processor.sym} 650 -340 0 0 {name=x1}
C {epc.sym} 650 -480 0 0 {name=x2}
C {devices/lab_wire.sym} 500 -380 0 0 {name=p1 sig_type=std_logic lab=vddd}
C {devices/lab_wire.sym} 500 -540 0 0 {name=p2 sig_type=std_logic lab=vdda}
C {devices/lab_wire.sym} 500 -300 0 0 {name=p3 sig_type=std_logic lab=vssd}
C {devices/lab_wire.sym} 500 -440 0 0 {name=p4 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} 500 -500 0 0 {name=p5 sig_type=std_logic lab=vinp}
C {devices/lab_wire.sym} 500 -480 0 0 {name=p6 sig_type=std_logic lab=vinn}
C {devices/lab_wire.sym} 500 -600 0 0 {name=p7 sig_type=std_logic lab=ckc}
C {devices/lab_wire.sym} 800 -540 0 1 {name=p8 sig_type=std_logic lab=comp_p}
C {devices/lab_wire.sym} 800 -520 0 1 {name=p9 sig_type=std_logic lab=comp_n}
C {devices/lab_wire.sym} 500 -360 0 0 {name=p10 sig_type=std_logic lab=comp_p}
C {devices/lab_wire.sym} 500 -340 0 0 {name=p11 sig_type=std_logic lab=comp_n}
C {devices/lab_wire.sym} 800 -380 0 1 {name=p12 sig_type=std_logic lab=comp}
C {devices/lab_wire.sym} 800 -360 0 1 {name=p13 sig_type=std_logic lab=rdy}
C {ckc_shifter.sym} 650 -600 0 0 {name=x3}
C {devices/lab_wire.sym} 500 -620 0 0 {name=p14 sig_type=std_logic lab=vddd}
C {devices/lab_wire.sym} 500 -580 0 0 {name=p15 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} 500 -460 0 0 {name=p16 sig_type=std_logic lab=clk}
C {devices/lab_wire.sym} 800 -620 0 1 {name=p17 sig_type=std_logic lab=clk}
C {devices/lab_wire.sym} 800 -600 0 1 {name=p18 sig_type=std_logic lab=clks}
C {devices/lab_wire.sym} 500 -320 0 0 {name=p19 sig_type=std_logic lab=clks}
C {devices/lab_wire.sym} 500 -420 0 0 {name=p22 sig_type=std_logic lab=vssd}
C {devices/lab_wire.sym} 500 -520 0 0 {name=p23 sig_type=std_logic lab=vddd}
C {devices/ipin.sym} 240 -560 0 0 {name=p20 sig_type=std_logic lab=vddd}
C {devices/ipin.sym} 240 -540 0 0 {name=p21 sig_type=std_logic lab=vdda}
C {devices/ipin.sym} 240 -520 0 0 {name=p24 sig_type=std_logic lab=ckc}
C {devices/ipin.sym} 240 -500 0 0 {name=p25 sig_type=std_logic lab=vinp}
C {devices/ipin.sym} 240 -480 0 0 {name=p26 sig_type=std_logic lab=vinn}
C {devices/ipin.sym} 240 -460 0 0 {name=p27 sig_type=std_logic lab=vssd}
C {devices/ipin.sym} 240 -440 0 0 {name=p28 sig_type=std_logic lab=vssa}
C {devices/opin.sym} 220 -400 0 0 {name=p29 sig_type=std_logic lab=comp}
C {devices/opin.sym} 220 -380 0 0 {name=p30 sig_type=std_logic lab=rdy}
