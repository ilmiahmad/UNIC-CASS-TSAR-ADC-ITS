v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 140 -400 0 0 {name=p20 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 140 -300 0 0 {name=p22 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 340 -430 0 0 {name=p1 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 340 -160 0 0 {name=p3 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 340 -310 0 0 {name=p4 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 340 -350 0 0 {name=p10 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 340 -60 0 0 {name=p12 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 340 -210 0 0 {name=p13 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 340 -410 0 0 {name=p29 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 340 -370 0 0 {name=p30 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 340 -230 0 0 {name=p32 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 340 -80 0 0 {name=p33 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 640 -410 0 1 {name=p34 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 340 -140 0 0 {name=p35 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 340 -290 0 0 {name=p36 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 640 -430 0 1 {name=p37 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 340 -250 0 0 {name=p38 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 640 -310 0 1 {name=p39 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 640 -290 0 1 {name=p40 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 340 -120 0 0 {name=p41 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 640 -160 0 1 {name=p42 sig_type=std_logic lab=DOUT[0:9]}
C {devices/lab_wire.sym} 640 -140 0 1 {name=p43 sig_type=std_logic lab=CKO}
C {devices/ipin.sym} 140 -360 0 0 {name=p7 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 140 -340 0 0 {name=p9 sig_type=std_logic lab=COMP_P}
C {devices/opin.sym} 140 -240 0 0 {name=p49 sig_type=std_logic lab=CF[0:9]}
C {devices/opin.sym} 140 -220 0 0 {name=p50 sig_type=std_logic lab=SWP[0:9]}
C {devices/opin.sym} 140 -200 0 0 {name=p51 sig_type=std_logic lab=SWN[0:9]}
C {devices/opin.sym} 140 -180 0 0 {name=p52 sig_type=std_logic lab=DOUT[0:9]}
C {devices/opin.sym} 140 -160 0 0 {name=p53 sig_type=std_logic lab=CKO}
C {devices/opin.sym} 140 -140 0 0 {name=p24 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 340 -270 0 0 {name=p6 sig_type=std_logic lab=COMP_N}
C {devices/ipin.sym} 140 -320 0 0 {name=p11 sig_type=std_logic lab=COMP_N}
C {devices/ipin.sym} 140 -380 0 0 {name=p14 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 340 -100 0 0 {name=p16 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 340 -390 0 0 {name=p17 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 340 -550 0 0 {name=p2 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 340 -490 0 0 {name=p5 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 340 -530 0 0 {name=p54 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 640 -550 0 1 {name=p55 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 640 -530 0 1 {name=p56 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 340 -510 0 0 {name=p57 sig_type=std_logic lab=EN}
C {devices/opin.sym} 140 -120 0 0 {name=p8 sig_type=std_logic lab=CLKSB}
C {/home/raditya/Documents/Projects/tsar_adc/xschem/auto_sampling.sym} 490 -520 0 0 {name=x2}
C {/home/raditya/Documents/Projects/tsar_adc/xschem/cyclic_flag.sym} 490 -390 0 0 {name=x1}
C {/home/raditya/Documents/Projects/tsar_adc/xschem/cdac_ctrl.sym} 490 -260 0 0 {name=x3}
C {/home/raditya/Documents/Projects/tsar_adc/xschem/out_latch.sym} 490 -110 0 0 {name=x4}
