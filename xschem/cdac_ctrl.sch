v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfrbp_2.sym} 370 -190 0 0 {name=x1[0:3] VGND=VSSD VNB=VSSD VPB=VDDD VPWR=VDDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_8.sym} 340 -80 0 0 {name=x1 VGND=VSSD VNB=VSSD VPB=VDDD VPWR=VDDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 280 -210 0 0 {name=p1 sig_type=std_logic lab=CF[0:3]}
C {devices/lab_wire.sym} 460 -210 0 1 {name=p2 sig_type=std_logic lab=SWP[0:3]}
C {devices/lab_wire.sym} 460 -190 0 1 {name=p3 sig_type=std_logic lab=SWN[0:3]}
C {devices/lab_wire.sym} 280 -190 0 0 {name=p4 sig_type=std_logic lab=COMP_BUF}
C {devices/lab_wire.sym} 280 -170 0 0 {name=p5 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 380 -80 0 1 {name=p6 sig_type=std_logic lab=COMP_BUF}
C {devices/lab_wire.sym} 300 -80 0 0 {name=p7 sig_type=std_logic lab=COMP}
C {devices/ipin.sym} 100 -220 0 0 {name=p15 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 100 -160 0 0 {name=p16 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 100 -140 0 0 {name=p17 sig_type=std_logic lab=VSSD}
C {devices/ipin.sym} 100 -200 0 0 {name=p8 sig_type=std_logic lab=COMP}
C {devices/ipin.sym} 100 -180 0 0 {name=p9 sig_type=std_logic lab=CF[0:3]}
C {devices/opin.sym} 100 -120 0 0 {name=p10 sig_type=std_logic lab=SWP[0:3]}
C {devices/opin.sym} 100 -100 0 0 {name=p11 sig_type=std_logic lab=SWN[0:3]}
