v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 640 -310 0 0 {name=C1 model=cap_mim_m3_2 W=dim L=dim MF=num spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 640 -200 0 0 {name=C2 model=cap_mim_m3_2 W=dim L=dim MF=num spiceprefix=X}
C {devices/lab_wire.sym} 640 -340 0 0 {name=p1 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 640 -230 0 0 {name=p2 sig_type=std_logic lab=vcn}
C {devices/lab_wire.sym} 640 -170 2 1 {name=p9 sig_type=std_logic lab=cdac_swn}
C {devices/lab_wire.sym} 640 -280 2 1 {name=p10 sig_type=std_logic lab=cdac_swp}
C {devices/iopin.sym} 200 -240 0 0 {name=p3 lab=vcp}
C {devices/iopin.sym} 200 -220 0 0 {name=p4 lab=vcn}
C {devices/ipin.sym} 200 -260 0 0 {name=p5 lab=cdac_swn}
C {devices/ipin.sym} 200 -280 0 0 {name=p6 lab=cdac_swp}
C {devices/param.sym} 300 -370 0 0 {name=s1 value="dim=1u num=1"}
