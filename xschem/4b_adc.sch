v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {4b_cdac_and_sw.sym} 430 -230 0 0 {name=x1}
C {th_sw.sym} 430 -410 0 0 {name=x2}
C {epc.sym} 890 -420 0 0 {name=x3}
C {sar.sym} 890 -210 0 0 {name=x4}
C {devices/lab_wire.sym} 280 -460 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 280 -280 0 0 {name=p2 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 740 -460 0 0 {name=p3 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 740 -380 0 0 {name=p4 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 280 -180 0 0 {name=p5 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 280 -360 0 0 {name=p6 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 740 -280 0 0 {name=p7 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 740 -200 0 0 {name=p8 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 280 -440 0 0 {name=p9 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -420 0 0 {name=p10 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 1040 -280 0 1 {name=p11 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 1040 -260 0 1 {name=p12 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 1040 -460 0 1 {name=p13 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 1040 -440 0 1 {name=p14 sig_type=std_logic lab=COMP_N}
C {devices/lab_wire.sym} 740 -240 0 0 {name=p15 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 740 -220 0 0 {name=p16 sig_type=std_logic lab=COMP_N}
C {devices/lab_wire.sym} 740 -260 0 0 {name=p17 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 580 -460 0 1 {name=p18 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 580 -440 0 1 {name=p19 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 580 -280 0 1 {name=p20 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 580 -260 0 1 {name=p21 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 740 -440 0 0 {name=p22 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 740 -420 0 0 {name=p23 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 1040 -140 0 1 {name=p24 sig_type=std_logic lab=CLK_NS}
C {devices/lab_wire.sym} 740 -400 0 0 {name=p25 sig_type=std_logic lab=CLK_NS}
C {devices/lab_wire.sym} 280 -260 0 0 {name=p26 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 280 -400 0 0 {name=p27 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 280 -380 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 280 -240 0 0 {name=p29 sig_type=std_logic lab=CF[0:3]}
C {devices/lab_wire.sym} 280 -220 0 0 {name=p30 sig_type=std_logic lab=SWP[0:3]}
C {devices/lab_wire.sym} 280 -200 0 0 {name=p31 sig_type=std_logic lab=SWN[0:3]}
C {devices/lab_wire.sym} 1040 -240 0 1 {name=p32 sig_type=std_logic lab=CF[0:3]}
C {devices/lab_wire.sym} 1040 -220 0 1 {name=p33 sig_type=std_logic lab=SWP[0:3]}
C {devices/lab_wire.sym} 1040 -200 0 1 {name=p34 sig_type=std_logic lab=SWN[0:3]}
C {devices/lab_wire.sym} 1040 -160 0 1 {name=p35 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 1040 -180 0 1 {name=p36 sig_type=std_logic lab=DOUT[0:3]}
C {devices/ipin.sym} 80 -480 0 0 {name=p37 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 80 -460 0 0 {name=p38 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 80 -440 0 0 {name=p39 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 80 -420 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 80 -400 0 0 {name=p41 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 80 -380 0 0 {name=p42 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 80 -360 0 0 {name=p43 sig_type=std_logic lab=VSSA}
C {devices/ipin.sym} 80 -340 0 0 {name=p44 sig_type=std_logic lab=VSSD}
C {devices/opin.sym} 80 -300 0 0 {name=p45 sig_type=std_logic lab=DOUT[0:3]}
C {devices/opin.sym} 80 -280 0 0 {name=p46 sig_type=std_logic lab=CKO}
