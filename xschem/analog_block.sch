v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 300 -330 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 300 -150 0 0 {name=p2 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 300 -50 0 0 {name=p5 sig_type=std_logic lab=VSSR}
C {devices/lab_wire.sym} 300 -230 0 0 {name=p6 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 300 -290 0 0 {name=p9 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 300 -310 0 0 {name=p10 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 600 -330 0 1 {name=p18 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 600 -310 0 1 {name=p19 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 600 -150 0 1 {name=p20 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 600 -130 0 1 {name=p21 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 300 -70 0 0 {name=p26 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 300 -270 0 0 {name=p27 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 300 -250 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 300 -130 0 0 {name=p29 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 300 -110 0 0 {name=p30 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 300 -90 0 0 {name=p31 sig_type=std_logic lab=SWN[0:9]}
C {cdac_10b.sym} 450 -100 0 0 {name=x1}
C {devices/lab_wire.sym} 300 -470 0 0 {name=p3 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 300 -390 0 0 {name=p4 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 300 -430 0 0 {name=p22 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 300 -410 0 0 {name=p23 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 300 -450 0 0 {name=p25 sig_type=std_logic lab=CLK}
C {tdc.sym} 450 -430 0 0 {name=x3}
C {devices/lab_wire.sym} 600 -470 0 1 {name=p13 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 600 -450 0 1 {name=p48 sig_type=std_logic lab=COMP_N}
C {devices/ipin.sym} 80 -400 0 0 {name=p37 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 80 -380 0 0 {name=p39 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 80 -300 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 80 -240 0 0 {name=p41 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 80 -220 0 0 {name=p42 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 80 -180 0 0 {name=p43 sig_type=std_logic lab=VSSA}
C {devices/ipin.sym} 80 -200 0 0 {name=p14 sig_type=std_logic lab=VSSR}
C {devices/ipin.sym} 80 -420 0 0 {name=p16 sig_type=std_logic lab=VDDR}
C {devices/opin.sym} 60 -120 0 0 {name=p50 sig_type=std_logic lab=COMP_P}
C {devices/opin.sym} 60 -100 0 0 {name=p51 sig_type=std_logic lab=COMP_N}
C {devices/ipin.sym} 80 -360 0 0 {name=p7 sig_type=std_logic lab=CF[0:9]}
C {devices/ipin.sym} 80 -340 0 0 {name=p8 sig_type=std_logic lab=SWP[0:9]}
C {devices/ipin.sym} 80 -320 0 0 {name=p11 sig_type=std_logic lab=SWN[0:9]}
C {devices/ipin.sym} 80 -260 0 0 {name=p12 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 80 -280 0 0 {name=p15 sig_type=std_logic lab=CLKSB}
C {th_sw.sym} 450 -280 0 0 {name=x2}
