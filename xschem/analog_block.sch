v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cdac_12b.sym} 810 -600 0 0 {name=x2}
C {th_switch.sym} 390 -600 0 0 {name=x1}
C {lab_wire.sym} 240 -650 0 0 {name=p1 sig_type=std_logic lab=vdda}
C {lab_wire.sym} 240 -550 0 0 {name=p2 sig_type=std_logic lab=vssa}
C {lab_wire.sym} 540 -650 0 1 {name=p3 sig_type=std_logic lab=vcp}
C {lab_wire.sym} 960 -650 0 1 {name=p4 sig_type=std_logic lab=vcp}
C {lab_wire.sym} 540 -630 0 1 {name=p5 sig_type=std_logic lab=vcn}
C {lab_wire.sym} 960 -630 0 1 {name=p6 sig_type=std_logic lab=vcn}
C {lab_wire.sym} 660 -650 0 0 {name=p7 sig_type=std_logic lab=vdref}
C {lab_wire.sym} 660 -550 0 0 {name=p8 sig_type=std_logic lab=vsref}
C {epc.sym} 390 -430 0 0 {name=x3}
C {lab_wire.sym} 240 -470 0 0 {name=p9 sig_type=std_logic lab=vdda}
C {lab_wire.sym} 240 -390 0 0 {name=p10 sig_type=std_logic lab=vssa}
C {lab_wire.sym} 240 -450 0 0 {name=p11 sig_type=std_logic lab=vcp}
C {lab_wire.sym} 240 -430 0 0 {name=p12 sig_type=std_logic lab=vcn}
C {lab_wire.sym} 240 -410 0 0 {name=p13 sig_type=std_logic lab=ckc}
C {lab_wire.sym} 240 -630 0 0 {name=p14 sig_type=std_logic lab=clks}
C {lab_wire.sym} 240 -610 0 0 {name=p15 sig_type=std_logic lab=clksb}
C {lab_wire.sym} 240 -590 0 0 {name=p16 sig_type=std_logic lab=vip}
C {lab_wire.sym} 240 -570 0 0 {name=p17 sig_type=std_logic lab=vin}
C {lab_wire.sym} 660 -630 0 0 {name=p18 sig_type=std_logic lab=cf[0:11]}
C {lab_wire.sym} 660 -610 0 0 {name=p19 sig_type=std_logic lab=swp[0:11]}
C {lab_wire.sym} 660 -590 0 0 {name=p20 sig_type=std_logic lab=swn[0:11]}
C {lab_wire.sym} 660 -570 0 0 {name=p21 sig_type=std_logic lab=vcm}
C {lab_wire.sym} 540 -470 0 1 {name=p22 sig_type=std_logic lab=comp_p}
C {lab_wire.sym} 540 -450 0 1 {name=p23 sig_type=std_logic lab=comp_n}
C {ipin.sym} 100 -640 0 0 {name=p24 lab=vdda}
C {ipin.sym} 100 -620 0 0 {name=p25 lab=clks}
C {ipin.sym} 100 -600 0 0 {name=p26 lab=clksb}
C {ipin.sym} 100 -580 0 0 {name=p27 lab=vip}
C {ipin.sym} 100 -560 0 0 {name=p28 lab=vin}
C {ipin.sym} 100 -540 0 0 {name=p29 lab=cf[0:11]}
C {ipin.sym} 100 -520 0 0 {name=p30 lab=swp[0:11]}
C {ipin.sym} 100 -500 0 0 {name=p31 lab=swn[0:11]}
C {ipin.sym} 100 -480 0 0 {name=p32 lab=ckc}
C {ipin.sym} 100 -460 0 0 {name=p33 lab=vcm}
C {ipin.sym} 100 -440 0 0 {name=p34 lab=vssa}
C {opin.sym} 80 -400 0 0 {name=p35 lab=comp_p}
C {opin.sym} 80 -380 0 0 {name=p36 lab=comp_n}
C {ipin.sym} 100 -660 0 0 {name=p37 lab=vdref}
C {ipin.sym} 100 -420 0 0 {name=p38 lab=vsref}
